# IAR project DS0201_APP.ewp, settings and files
configuration FLASH (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: VECT_TAB_FLASH
  ICCARM.CCIncludePath2: ..\..\..\library\inc; ..\..\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: DS0201_APP.hex
  ILINK.IlinkOutputFile: DS0201_APP.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../source/: ASM_Function.s Calculate.c Files.c Function.c HW_V1_Config.c Lcd.c main.c Menu.c stm32f10x_it.c stm32f10x_vector.c
  group EWARM
    ./: cortexm3_macro.s
  group STlib
    ../../../library/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c
